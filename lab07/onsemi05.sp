*----------------------------------------------------------------------
* Models from MOSIS electrical data.  There are two versions of each
* model; one with devices named NMOS & PMOS (as in W&H) and the other
* with devices named NFET & PFET (as generated by Magic exttospice)
*----------------------------------------------------------------------
* DATE: Mar 15/10
* LOT: T9BM                  WAF: 2102
* Temperature_parameters=Default
.MODEL NMOS NMOS (                                LEVEL   = 49
+VERSION = 3.1            TNOM    = 27             TOX     = 1.39E-8
+XJ      = 1.5E-7         NCH     = 1.7E17         VTH0    = 0.5916823
+K1      = 0.9970315      K2      = -0.1275822     K3      = 32.4012543
+K3B     = -7.5008412     W0      = 1.064896E-8    NLX     = 1E-9
+DVT0W   = 0              DVT1W   = 0              DVT2W   = 0
+DVT0    = 0.7187527      DVT1    = 0.3412308      DVT2    = -0.5
+U0      = 449.0974306    UA      = 1.085166E-13   UB      = 1.425387E-18
+UC      = -1.74612E-14   VSAT    = 1.669807E5     A0      = 0.5933847
+AGS     = 0.1035164      B0      = 1.668729E-6    B1      = 5E-6
+KETA    = -3.86833E-3    A1      = 2.152036E-4    A2      = 0.3536877
+RDSW    = 1.061307E3     PRWG    = 0.0822544      PRWB    = 1.740605E-5
+WR      = 1              WINT    = 2.482453E-7    LINT    = 7.591645E-8
+XL      = 1E-7           XW      = 0              DWG     = -1.279102E-8
+DWB     = 4.853492E-8    VOFF    = 0              NFACTOR = 0.9088018
+CIT     = 0              CDSC    = 2.4E-4         CDSCD   = 0
+CDSCB   = 0              ETA0    = 2.907125E-3    ETAB    = 0.9951793
+DSUB    = 0.0492559      PCLM    = 2.2082829      PDIBLC1 = 3.324146E-4
+PDIBLC2 = 1.488616E-3    PDIBLCB = -0.1429457     DROUT   = 8.319308E-5
+PSCBE1  = 2.516822E9     PSCBE2  = 5E-10          PVAG    = 0
+DELTA   = 0.01           RSH     = 84             MOBMOD  = 1
+PRT     = 0              UTE     = -1.5           KT1     = -0.11
+KT1L    = 0              KT2     = 0.022          UA1     = 4.31E-9
+UB1     = -7.61E-18      UC1     = -5.6E-11       AT      = 3.3E4
+WL      = 0              WLN     = 1              WW      = 0
+WWN     = 1              WWL     = 0              LL      = 0
+LLN     = 1              LW      = 0              LWN     = 1
+LWL     = 0              CAPMOD  = 2              XPART   = 0.5
+CGDO    = 1.82E-10       CGSO    = 1.82E-10       CGBO    = 1E-9
+CJ      = 4.29253E-4     PB      = 0.8858652      MJ      = 0.4353384
+CJSW    = 3.622458E-10   PBSW    = 0.8            MJSW    = 0.2339166
+CJSWG   = 1.64E-10       PBSWG   = 0.8            MJSWG   = 0.2339166
+CF      = 0              PVTH0   = -0.0504111     PRDSW   = 277.8034293
+PK2     = -0.0683031     WKETA   = 5.494298E-3    LKETA   = -6.64089E-3     )
*
.MODEL PMOS PMOS (                                LEVEL   = 49
+VERSION = 3.1            TNOM    = 27             TOX     = 1.39E-8
+XJ      = 1.5E-7         NCH     = 1.7E17         VTH0    = -0.9152268
+K1      = 0.553472       K2      = 7.871921E-3    K3      = 0.3045116
+K3B     = 0.4207623      W0      = 5.814395E-7    NLX     = 6.71009E-8
+DVT0W   = 0              DVT1W   = 0              DVT2W   = 0
+DVT0    = 0.6597447      DVT1    = 0.3261802      DVT2    = -0.3
+U0      = 201.3603195    UA      = 2.408572E-9    UB      = 1E-21
+UC      = -1E-10         VSAT    = 9.345943E4     A0      = 0.8172376
+AGS     = 0.097476       B0      = 5.101025E-7    B1      = 1.701779E-8
+KETA    = -4.865785E-3   A1      = 0              A2      = 0.6429159
+RDSW    = 3E3            PRWG    = -0.0280817     PRWB    = -0.0480265
+WR      = 1              WINT    = 2.908993E-7    LINT    = 1.225719E-7
+XL      = 1E-7           XW      = 0              DWG     = 1.554343E-9
+DWB     = -1.9281E-8     VOFF    = -0.0705167     NFACTOR = 1.016159
+CIT     = 0              CDSC    = 2.4E-4         CDSCD   = 0
+CDSCB   = 0              ETA0    = 6.97667E-4     ETAB    = -0.2
+DSUB    = 1              PCLM    = 2.4034299      PDIBLC1 = 0.0525071
+PDIBLC2 = 3.609644E-3    PDIBLCB = -0.0206211     DROUT   = 0.2542493
+PSCBE1  = 1E8            PSCBE2  = 3.365142E-9    PVAG    = 0.0150027
+DELTA   = 0.01           RSH     = 107.2          MOBMOD  = 1
+PRT     = 0              UTE     = -1.5           KT1     = -0.11
+KT1L    = 0              KT2     = 0.022          UA1     = 4.31E-9
+UB1     = -7.61E-18      UC1     = -5.6E-11       AT      = 3.3E4
+WL      = 0              WLN     = 1              WW      = 0
+WWN     = 1              WWL     = 0              LL      = 0
+LLN     = 1              LW      = 0              LWN     = 1
+LWL     = 0              CAPMOD  = 2              XPART   = 0.5
+CGDO    = 2.22E-10       CGSO    = 2.22E-10       CGBO    = 1E-9
+CJ      = 7.306902E-4    PB      = 0.9419671      MJ      = 0.4929212
+CJSW    = 2.535867E-10   PBSW    = 0.8            MJSW    = 0.3168453
+CJSWG   = 6.4E-11        PBSWG   = 0.8            MJSWG   = 0.3168453
+CF      = 0              PVTH0   = 5.98016E-3     PRDSW   = 14.8598424
+PK2     = 3.73981E-3     WKETA   = 1.137045E-4    LKETA   = -9.773144E-3    )
*
*----------------------------------------------------------------------
* same model renamed NMOS, PMOS
*----------------------------------------------------------------------
* DATE: Mar 15/10
* LOT: T9BM                  WAF: 2102
* Temperature_parameters=Default
.MODEL NFET NMOS (                                LEVEL   = 49
+VERSION = 3.1            TNOM    = 27             TOX     = 1.39E-8
+XJ      = 1.5E-7         NCH     = 1.7E17         VTH0    = 0.5916823
+K1      = 0.9970315      K2      = -0.1275822     K3      = 32.4012543
+K3B     = -7.5008412     W0      = 1.064896E-8    NLX     = 1E-9
+DVT0W   = 0              DVT1W   = 0              DVT2W   = 0
+DVT0    = 0.7187527      DVT1    = 0.3412308      DVT2    = -0.5
+U0      = 449.0974306    UA      = 1.085166E-13   UB      = 1.425387E-18
+UC      = -1.74612E-14   VSAT    = 1.669807E5     A0      = 0.5933847
+AGS     = 0.1035164      B0      = 1.668729E-6    B1      = 5E-6
+KETA    = -3.86833E-3    A1      = 2.152036E-4    A2      = 0.3536877
+RDSW    = 1.061307E3     PRWG    = 0.0822544      PRWB    = 1.740605E-5
+WR      = 1              WINT    = 2.482453E-7    LINT    = 7.591645E-8
+XL      = 1E-7           XW      = 0              DWG     = -1.279102E-8
+DWB     = 4.853492E-8    VOFF    = 0              NFACTOR = 0.9088018
+CIT     = 0              CDSC    = 2.4E-4         CDSCD   = 0
+CDSCB   = 0              ETA0    = 2.907125E-3    ETAB    = 0.9951793
+DSUB    = 0.0492559      PCLM    = 2.2082829      PDIBLC1 = 3.324146E-4
+PDIBLC2 = 1.488616E-3    PDIBLCB = -0.1429457     DROUT   = 8.319308E-5
+PSCBE1  = 2.516822E9     PSCBE2  = 5E-10          PVAG    = 0
+DELTA   = 0.01           RSH     = 84             MOBMOD  = 1
+PRT     = 0              UTE     = -1.5           KT1     = -0.11
+KT1L    = 0              KT2     = 0.022          UA1     = 4.31E-9
+UB1     = -7.61E-18      UC1     = -5.6E-11       AT      = 3.3E4
+WL      = 0              WLN     = 1              WW      = 0
+WWN     = 1              WWL     = 0              LL      = 0
+LLN     = 1              LW      = 0              LWN     = 1
+LWL     = 0              CAPMOD  = 2              XPART   = 0.5
+CGDO    = 1.82E-10       CGSO    = 1.82E-10       CGBO    = 1E-9
+CJ      = 4.29253E-4     PB      = 0.8858652      MJ      = 0.4353384
+CJSW    = 3.622458E-10   PBSW    = 0.8            MJSW    = 0.2339166
+CJSWG   = 1.64E-10       PBSWG   = 0.8            MJSWG   = 0.2339166
+CF      = 0              PVTH0   = -0.0504111     PRDSW   = 277.8034293
+PK2     = -0.0683031     WKETA   = 5.494298E-3    LKETA   = -6.64089E-3     )
*
.MODEL PFET PMOS (                                LEVEL   = 49
+VERSION = 3.1            TNOM    = 27             TOX     = 1.39E-8
+XJ      = 1.5E-7         NCH     = 1.7E17         VTH0    = -0.9152268
+K1      = 0.553472       K2      = 7.871921E-3    K3      = 0.3045116
+K3B     = 0.4207623      W0      = 5.814395E-7    NLX     = 6.71009E-8
+DVT0W   = 0              DVT1W   = 0              DVT2W   = 0
+DVT0    = 0.6597447      DVT1    = 0.3261802      DVT2    = -0.3
+U0      = 201.3603195    UA      = 2.408572E-9    UB      = 1E-21
+UC      = -1E-10         VSAT    = 9.345943E4     A0      = 0.8172376
+AGS     = 0.097476       B0      = 5.101025E-7    B1      = 1.701779E-8
+KETA    = -4.865785E-3   A1      = 0              A2      = 0.6429159
+RDSW    = 3E3            PRWG    = -0.0280817     PRWB    = -0.0480265
+WR      = 1              WINT    = 2.908993E-7    LINT    = 1.225719E-7
+XL      = 1E-7           XW      = 0              DWG     = 1.554343E-9
+DWB     = -1.9281E-8     VOFF    = -0.0705167     NFACTOR = 1.016159
+CIT     = 0              CDSC    = 2.4E-4         CDSCD   = 0
+CDSCB   = 0              ETA0    = 6.97667E-4     ETAB    = -0.2
+DSUB    = 1              PCLM    = 2.4034299      PDIBLC1 = 0.0525071
+PDIBLC2 = 3.609644E-3    PDIBLCB = -0.0206211     DROUT   = 0.2542493
+PSCBE1  = 1E8            PSCBE2  = 3.365142E-9    PVAG    = 0.0150027
+DELTA   = 0.01           RSH     = 107.2          MOBMOD  = 1
+PRT     = 0              UTE     = -1.5           KT1     = -0.11
+KT1L    = 0              KT2     = 0.022          UA1     = 4.31E-9
+UB1     = -7.61E-18      UC1     = -5.6E-11       AT      = 3.3E4
+WL      = 0              WLN     = 1              WW      = 0
+WWN     = 1              WWL     = 0              LL      = 0
+LLN     = 1              LW      = 0              LWN     = 1
+LWL     = 0              CAPMOD  = 2              XPART   = 0.5
+CGDO    = 2.22E-10       CGSO    = 2.22E-10       CGBO    = 1E-9
+CJ      = 7.306902E-4    PB      = 0.9419671      MJ      = 0.4929212
+CJSW    = 2.535867E-10   PBSW    = 0.8            MJSW    = 0.3168453
+CJSWG   = 6.4E-11        PBSWG   = 0.8            MJSWG   = 0.3168453
+CF      = 0              PVTH0   = 5.98016E-3     PRDSW   = 14.8598424
+PK2     = 3.73981E-3     WKETA   = 1.137045E-4    LKETA   = -9.773144E-3    )
*
